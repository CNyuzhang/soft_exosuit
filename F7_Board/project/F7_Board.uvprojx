# Keil uVision project F7_Board.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: F7_Board
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx
  c include: ..\src\SYSTEM\delay;..\src\SYSTEM\sys;..\src\SYSTEM\usart;..\src\HARDWARE\LED;..\src\HARDWARE\KEY;..\src\HARDWARE\EXTI;..\src\HARDWARE\WDG;..\src\HARDWARE\TIMER;..\src\HARDWARE\TPAD;..\src\HARDWARE\MPU;..\src\HARDWARE\SDRAM;..\src\USMART;..\src\HARDWARE\RTC;..\src\HARDWARE\CAN;..\src\HARDWARE\LCD;..\src\HARDWARE\COPLEY;..\src\HARDWARE\USART;..\src\app;..\src\ANO;..\src\HARDWARE\soft_switch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group app
    ../src/app/: test.c pid.c lrn.c
  group startup
    ../src/startup/: startup_stm32f767xx.s
  group hardware
    ../src/HARDWARE/MPU/: mpu.c
    ../src/HARDWARE/SDRAM/: sdram.c
    ../src/HARDWARE/CAN/: can.c
    ../src/HARDWARE/COPLEY/: copley_control.c copley_node1.c copley_node2.c
    ../src/HARDWARE/USART/: uart.c
    ../src/HARDWARE/soft_switch/: soft_switch.c
    ../src/HARDWARE/TIMER/: timer.c
  group usmart
    ../src/USMART/: usmart.c usmart_config.c usmart_str.c
  group system
    ../src/SYSTEM/delay/: delay.c
    ../src/SYSTEM/sys/: sys.c
    ../src/SYSTEM/usart/: usart.c
  group ano
    ../src/ANO/: ANO.c
